# Keil uVision project net_rs232.uvprojx, settings and files
target NET_RS232 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: net_rs232 +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\USER;.\CORE;.\SYSTEM;.\HARDWARE;.\FWLIB;.\FWLIB\STM32F4x7_ETH_Driver\inc;.\FWLIB\STM32F4xx_StdPeriph_Driver\inc;.\LWIP;.\LWIP\arch;.\LWIP\lwip-1.4.1\src\include;.\LWIP\lwip-1.4.1\src\include\ipv4;.\LWIP\lwip-1.4.1\src\include\lwip;.\LWIP\lwip-1.4.1\src\include\netif;.\HTTP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWLIB
    ./FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_iwdg.c
    ./FWLIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group SYS
    ./SYSTEM/: delay.c malloc.c msg_interface.c wdg.c
  group HW
    ./HARDWARE/: console.c debug_led.c fsmc.c lan8720.c lwip_comm.c uart_fsmc.c config.c udp_interface.c
  group USER
    ./USER/: main.c msg_handlers.c timer.c stm32f4xx_it.c system_stm32f4xx.c protocol_layer.c
  group LWIP-NETIF
    ./LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group LWIP-CORE
    ./LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP-ARCH
    ./LWIP/arch/: sys_arch.c
  group LWIP-API
    ./LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group HTTP
    ./HTTP/: fs.c httpd.c httpd_cgi_ssi.c
  group CORE
    ./CORE/: startup_stm32f40_41xxx.s
